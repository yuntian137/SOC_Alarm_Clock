# Keil uVision project Comp.uvprojx, settings and files
target <Comp> (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: SC32F10TS8 SinOneMicroelectronics
  pack: SinOne.SC32F1xxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Comp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: SC32f10xx
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS;..\Buzz\Inc;..\Drivers\TKDriver\C;..\Mqtt\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c Delay.c
  group Apps
    ../Apps/: UART_Communication_DMA.C UART_Communication.C TIM_TI_DMA.C
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_dma.c sc32f1xxx_uart.c sc32f1xxx_tim.c sc32f1xxx_adc.c sc32f1xxx_pwm.c sc32f1xxx_twi.c sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c
  group Startup
    ./: startup_sc32f10xx.s
  group Buzzer
    ../Buzz/Src/: Buzzer.c
  group TK_Divers
    ../Drivers/TKDriver/C/: sc32f10xx_TK_ParameterAnalysis.h TKDriver.C TKDriver.h S_TouchKeyCFG.h sc32f10xx_HighSensitive_lib_T1Slider_V0.3.lib
  group Mqtt
    ../Mqtt/Src/: mqtt.c
    ../Mqtt/Inc/: mqtt.h
